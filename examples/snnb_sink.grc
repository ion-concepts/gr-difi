options:
  parameters:
    generate_options: hb
    id: snnb_sink
    output_language: python
    title: SNNB Sink
  states: {}

blocks:
- name: difi_sink_cpp_0
  id: difi_sink_cpp
  parameters:
    bit_depth: '8'
    context_pack_size: '84'
    context_packet_send_count: '1000'
    data_size: '722'
    if_gain_dB: '0'
    ip_addr: ip_addr
    mode: 'True'
    port: port
    protocol: '2'
    reference_time_frac: '0'
    reference_time_full: '0'
    rf_gain_dB: '63'
    sample_rate: int(samp_rate)
    stream_id: '0'
    type: complex
  states: {}
- name: difi_source_cpp_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    context_behavior: '0'
    ip_addr: ip_addr
    port: port
    protocol: '2'
    stream_num: '0'
    type: complex
  states: {}
- name: difi_synchronize_0
  id: difi_synchronize
  parameters:
    comment: |-
      To use this pair of DIFI Sink/Sources in paired mode 
      set "Share tags" to True so that context extension packets 
      are passed from synchro port to the output and looped
      back to the SNNB
    share_tags: 'True'
    type: complex
    vlen: '1'
  states: {}
- name: ip_addr
  id: parameter
  parameters:
    label: IP Address
    type: str
    value: 192.168.10.20
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    comment: |-
      out port allows debug to 
      be hooked up externally.
    label: tx_monitor
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    comment: |-
      rx_out port streams received samples
      with tags from VITA49.0.
    label: rx_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: tx_in
    type: complex
  states: {}
- name: port
  id: parameter
  parameters:
    label: Port
    type: intx
    value: '50000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '4000000'
  states: {}

connections:
- [difi_source_cpp_0, '0', difi_synchronize_0, '1']
- [difi_source_cpp_0, '0', pad_sink_0_0, '0']
- [difi_synchronize_0, '0', difi_sink_cpp_0, '0']
- [difi_synchronize_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', difi_synchronize_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
