options:
  parameters:
    generate_options: hb
    id: spectralnet_sink_src
    output_language: python
    title: SpectralNet Sink and Source
  states: {}

blocks:
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Scale output by 1/128 because 
      SpectralNet/DIFI Source fails to normalize to +1/-1
    const: 1/128
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    comment: |-
      Padding stream of zero's used when
      input stream is idle.
    type: complex
  states: {state: disabled}
- name: difi_sink_cpp_0
  id: difi_sink_cpp
  parameters:
    bit_depth: '8'
    comment: |-
      SNNB sends TX stream, rate controlled by RX. 
      We need enough data buffered at the SNNB to 
      buffer any transport jitter so no underflows occur.
    context_pack_size: '84'
    context_packet_send_count: '1000'
    data_size: '722'
    gain: '1.0'
    if_gain_dB: '0'
    ip_addr: tx_ip_addr
    max_iq: '1.0'
    min_iq: '-1.0'
    mode: 'True'
    offset: '0'
    port: tx_port
    protocol: '2'
    reference_time_frac: '0'
    reference_time_full: '0'
    rf_gain_dB: '63'
    sample_rate: int(samp_rate)
    scaling: '2'
    stream_id: '0'
    type: complex
  states: {}
- name: difi_source_cpp_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    comment: |-
      SNNB RX sources a sample a sample stream of identical 
      rate to the TX stream becasue they share the same clock reference.
      Sample data is to be discarded but interleaved context extension 
      packets can be turned into GR tags and used to gerenate the expected
      context extension packets on the RX stream.
    context_behavior: '0'
    ip_addr: tx_ip_addr
    port: tx_port
    protocol: '2'
    stream_num: '0'
    type: complex
  states: {}
- name: difi_source_cpp_0_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    comment: SNWB is support in VITA49.2 by DIFI Source so can use as-is.
    context_behavior: '0'
    ip_addr: rx_ip_addr
    port: rx_port
    protocol: '2'
    stream_num: '0'
    type: complex
  states: {}
- name: difi_synchronize_0
  id: difi_synchronize
  parameters:
    comment: |-
      To use this pair of DIFI Sink/Sources in paired mode 
      set "Share tags" to True so that context extension packets 
      are passed from synchro port to the output and looped
      back to the SNNB
    share_tags: 'True'
    type: complex
    vlen: '1'
  states: {}
- name: lr_wpan_baz_merge_0
  id: lr_wpan_baz_merge
  parameters:
    additional_streams: '2'
    comment: |-
      "baz_merge" allows an intermittant bursty stream to 
      interupt (or be padded by) a continious stream
    drop_residual: 'True'
    ignore_tag: ''
    item_size: complex
    length_tag: packet_len
    samp_rate: samp_rate
    verbose: 'True'
  states: {state: disabled}
- name: lr_wpan_burst_to_stream_0
  id: lr_wpan_burst_to_stream
  parameters:
    comment: |-
      Burst_to_Stream zero fills between Bursts (Packets) 
      since there is no burst support in the SNNB.
    len_tag_key: '"packet_len"'
    propagate_tags: 'False'
    type: complex
    vlen: '1'
  states: {state: bypassed}
- name: pad_sink_0
  id: pad_sink
  parameters:
    comment: |-
      out port allows debug to 
      be hooked up externally.
    label: tx_monitor
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    comment: |-
      rx_pace_out port streams received samples
      with tags from SNNB using VITA49.0.
    label: rx_rate_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    comment: |-
      rx_out port streams received samples
      with tags from SNWB using VITA49.2.
    label: rx_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: tx_in
    type: complex
  states: {}
- name: rx_ip_addr
  id: parameter
  parameters:
    label: RX IP Address
    type: str
    value: 192.168.40.20
  states: {}
- name: rx_port
  id: parameter
  parameters:
    label: RX Port
    type: intx
    value: '50001'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '4000000'
  states: {}
- name: tx_ip_addr
  id: parameter
  parameters:
    label: TX IP Address
    type: str
    value: 192.168.10.20
  states: {}
- name: tx_port
  id: parameter
  parameters:
    label: TX Port
    type: intx
    value: '50000'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', pad_sink_0_0_0, '0']
- [blocks_null_source_0, '0', lr_wpan_baz_merge_0, '0']
- [difi_source_cpp_0, '0', difi_synchronize_0, '1']
- [difi_source_cpp_0, '0', pad_sink_0_0, '0']
- [difi_source_cpp_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [difi_synchronize_0, '0', difi_sink_cpp_0, '0']
- [difi_synchronize_0, '0', pad_sink_0, '0']
- [lr_wpan_baz_merge_0, '0', difi_synchronize_0, '0']
- [lr_wpan_burst_to_stream_0, '0', difi_synchronize_0, '0']
- [pad_source_0, '0', lr_wpan_baz_merge_0, '1']
- [pad_source_0, '0', lr_wpan_burst_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
