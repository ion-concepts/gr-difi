options:
  parameters:
    generate_options: qt_gui
    id: test_difi_consortium_paired
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cw_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1.90'
    value: '1.0'
  states: {}
- name: cw_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: '1000000'
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '25000'
    stop: 3e9
    value: 1.2e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '32'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: rx_gain
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: cw_amp
    freq: cw_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: difi_sink_cpp_0
  id: difi_sink_cpp
  parameters:
    bit_depth: '8'
    context_pack_size: '84'
    context_packet_send_count: '1000'
    data_size: '722'
    gain: '1.0'
    if_gain_dB: '0'
    ip_addr: 192.168.10.20
    max_iq: '1.0'
    min_iq: '-1.0'
    mode: 'False'
    offset: '0'
    port: '50000'
    protocol: '2'
    reference_time_frac: '0'
    reference_time_full: '0'
    rf_gain_dB: '63'
    sample_rate: samp_rate
    scaling: '2'
    stream_id: '0'
    type: complex
  states: {}
- name: difi_source_cpp_0
  id: difi_source_cpp
  parameters:
    bit_depth: '8'
    context_behavior: '0'
    ip_addr: 192.168.10.20
    port: '50000'
    protocol: '2'
    stream_num: '0'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '3'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tx_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', difi_sink_cpp_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_xx_0, '1']
- [difi_source_cpp_0, '0', blocks_tag_debug_0, '0']
- [difi_source_cpp_0, '0', blocks_tag_gate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
