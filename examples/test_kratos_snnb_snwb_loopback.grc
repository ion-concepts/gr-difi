options:
  parameters:
    generate_options: qt_gui
    id: test_kratos_snnb_snwb_loopback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cw_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '2.0'
    value: '1'
  states: {}
- name: cw_freq
  id: variable_qtgui_range
  parameters:
    start: '-2e6'
    step: '1'
    stop: 2e6
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cw_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: spectralnet_sink_src_0
  id: spectralnet_sink_src
  parameters:
    rx_ip_addr: 192.168.40.20
    rx_port: '50001'
    samp_rate: '4000000'
    tx_ip_addr: 192.168.10.20
    tx_port: '50000'
  states: {}

connections:
- [analog_sig_source_x_0, '0', spectralnet_sink_src_0, '0']
- [spectralnet_sink_src_0, '0', qtgui_freq_sink_x_0_0, '0']
- [spectralnet_sink_src_0, '2', qtgui_freq_sink_x_0, '0']
- [spectralnet_sink_src_0, '2', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
